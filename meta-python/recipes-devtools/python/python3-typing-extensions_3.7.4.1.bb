inherit setuptools3
require python-typing-extensions.inc
